# Keil uVision project dpp-qxk.uvprojx, settings and files
target dpp-dbg (6210000::V6.21::ARMCLANG)
  device: STM32C031C6Tx STMicroelectronics
  pack: Keil.STM32C0xx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00003000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: dpp-qxk
  BeforeMake: cmd /c "del .\dbg\qstamp.o"
  AfterMake: fromelf --bin --output .\dbg\dpp-qxk.bin .\dbg\dpp-qxk.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: QP_CONFIG
  c include: ..\..;..\..\..\..\..\include;..\..\..\..\..\ports\arm-cm\qxk\armclang;..\..\..\..\..\3rd_party\CMSIS\Include;..\..\..\..\..\3rd_party\nucleo-c031c6
  asm define: Stack_Size=2048 Heap_Size=16
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x3000
  scatter file: .\dpp-qxk.sct
  link misc: --entry Reset_Handler
  group Source Code
    ../: bsp.cpp xthread1.cpp xthread2.cpp
    ../../: bsp.hpp dpp.hpp philo.cpp table.cpp main.cpp qp_config.hpp
    ./: dpp-qxk.sct
  group nucleo-c031c6
    ../../../../../3rd_party/nucleo-c031c6/: stm32c0xx.h stm32c031xx.h system_stm32c0xx.c
    ../../../../../3rd_party/nucleo-c031c6/arm/: startup_stm32c031xx.s
  group QP
    ../../../../../src/qf/: qep_hsm.cpp qep_msm.cpp qf_act.cpp qf_actq.cpp qf_defer.cpp qf_dyn.cpp qf_mem.cpp qf_ps.cpp qf_qact.cpp qf_qeq.cpp qf_qmact.cpp qf_time.cpp
    ../../../../../src/qxk/: qxk.cpp qxk_mutex.cpp qxk_sema.cpp qxk_xthr.cpp
  group QP_port
    ../../../../../ports/arm-cm/qxk/armclang/: qs_port.hpp qxk_port.cpp qp_port.hpp
  group QS
    ../../../../../src/qs/: qs.cpp qs_64bit.cpp qs_fp.cpp qs_rx.cpp qstamp.cpp
target dpp-rel (6160000::V6.16::ARMCLANG)
  device: STM32C031C6Tx STMicroelectronics
  pack: Keil.STM32C0xx_DFP.1.0.0
  cpu: as above
  output: dpp-qxk
  BeforeMake: cmd /c "del .\rel\qstamp.o"
  AfterMake: fromelf --bin --output .\rel\dpp-qxk.bin .\rel\dpp-qxk.axf
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG,QP_CONFIG
  c include: as above
  asm define: Stack_Size=2048 Heap_Size=16
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x3000
  scatter file: .\dpp-qxk.sct
  link misc: --entry Reset_Handler
target dpp-spy (6210000::V6.21::ARMCLANG)
  device: STM32C031C6Tx STMicroelectronics
  pack: Keil.STM32C0xx_DFP.1.0.0
  cpu: as above
  output: dpp-qxk
  BeforeMake: cmd /c "del .\spy\qstamp.o"
  AfterMake: fromelf --bin --output .\spy\dpp-qxk.bin .\spy\dpp-qxk.axf
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: Q_SPY,QP_CONFIG
  c include: as above
  asm define: Stack_Size=2048 Heap_Size=16
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x3000
  scatter file: .\dpp-qxk.sct
  link misc: --entry Reset_Handler
