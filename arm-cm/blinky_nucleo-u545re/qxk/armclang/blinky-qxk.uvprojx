# Keil uVision project blinky-qxk.uvprojx, settings and files
target blinky-dbg (6220000::V6.22::ARMCLANG)
  device: STM32U545RETxQ STMicroelectronics
  pack: Keil.STM32U5xx_DFP.2.2.1
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x28000000,0x00004000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: blinky-qxk
  BeforeMake: cmd /c "del .\dbg\qstamp.o"
  AfterMake: fromelf --bin --output .\dbg\blinky-qxk.bin .\dbg\blinky-qxk.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32U545xx
  c include: ..\..;..\..\..\..\..\include;..\..\..\..\..\ports\arm-cm\qxk\armclang;..\..\..\..\..\3rd_party\CMSIS\Include;..\..\..\..\..\3rd_party\nucleo-u545re
  asm define: Stack_Size=2048 Heap_Size=16
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x28000000 size 0x4000
  scatter file: .\blinky-qxk.sct
  link misc: --entry Reset_Handler
  group Source Code
    ../: bsp.cpp xthr.cpp
    ../../: bsp.hpp app.hpp blinky.cpp main.cpp qp_config.hpp
    ./: blinky-qxk.sct
  group nucleo-u545re
    ../../../../../3rd_party/nucleo-u545re/: stm32u5xx.h stm32u545xx.h system_stm32u5xx.c
    ../../../../../3rd_party/nucleo-u545re/arm/: startup_stm32u545retxq.s
  group QP
    ../../../../../src/qf/: qep_hsm.cpp qep_msm.cpp qf_act.cpp qf_actq.cpp qf_defer.cpp qf_dyn.cpp qf_mem.cpp qf_ps.cpp qf_qact.cpp qf_qeq.cpp qf_qmact.cpp qf_time.cpp
    ../../../../../src/qxk/: qxk.cpp qxk_mutex.cpp qxk_sema.cpp qxk_xthr.cpp
  group QP_port
    ../../../../../ports/arm-cm/qxk/armclang/: qs_port.hpp qxk_port.cpp qp_port.hpp
  group QS
    ../../../../../src/qs/: qs.cpp qs_64bit.cpp qs_fp.cpp qs_rx.cpp qstamp.cpp
target blinky-rel (6210000::V6.21::ARMCLANG)
  device: STM32U545RETxQ STMicroelectronics
  pack: Keil.STM32U5xx_DFP.2.2.1
  cpu: as above
  output: blinky-qxk
  BeforeMake: cmd /c "del .\rel\qstamp.o"
  AfterMake: fromelf --bin --output .\rel\blinky-qxk.bin .\rel\blinky-qxk.axf
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG,STM32U545xx
  c include: as above
  asm define: Stack_Size=2048 Heap_Size=16
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x28000000 size 0x4000
  scatter file: .\blinky-qxk.sct
  link misc: --entry Reset_Handler
target blinky-spy (6220000::V6.22::ARMCLANG)
  device: STM32U545RETxQ STMicroelectronics
  pack: Keil.STM32U5xx_DFP.2.2.1
  cpu: as above
  output: blinky-qxk
  BeforeMake: cmd /c "del .\spy\qstamp.o"
  AfterMake: fromelf --bin --output .\spy\blinky-qxk.bin .\spy\blinky-qxk.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: Q_SPY,STM32U545xx
  c include: as above
  asm define: Stack_Size=2048 Heap_Size=16
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x28000000 size 0x4000
  scatter file: .\blinky-qxk.sct
  link misc: --entry Reset_Handler
