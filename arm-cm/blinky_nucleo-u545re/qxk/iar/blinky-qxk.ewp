# IAR project blinky-qxk.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32U575RG ST STM32U575RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: STM32U545xx
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..; ..\..\..\..\..\include; ..\..\..\..\..\ports\arm-cm\qxk\iar; ..\..\..\..\..\3rd_party\CMSIS\Include; ..\..\..\..\..\3rd_party\nucleo-u545re
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: blinky-qxk.bin
  prebuild: cmd /c "if exist $OBJ_DIR$\qstamp.o del $OBJ_DIR$\qstamp.o"
  ILINK.IlinkOutputFile: blinky-qxk.out
  ILINK.IlinkIcfFile: blinky-qxk.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STM32U545xx
  ICCARM.CCOptLevel: 3
configuration Spy (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: Q_SPY; STM32U545xx
  group Application
    ../../: blinky.cpp app.hpp bsp.hpp main.cpp qp_config.hpp
    ../: bsp.cpp xthr.cpp
  group nucleo-u545re
    ../../../../../3rd_party/nucleo-u545re/iar/: startup_stm32u545retxq.s
    ../../../../../3rd_party/nucleo-u545re/: stm32u545xx.h stm32u5xx.h system_stm32u5xx.c system_stm32u5xx.h
  group QP
    ../../../../../src/qf/: qep_hsm.cpp qep_msm.cpp qf_act.cpp qf_actq.cpp qf_defer.cpp qf_dyn.cpp qf_mem.cpp qf_ps.cpp qf_qact.cpp qf_qeq.cpp qf_qmact.cpp qf_time.cpp
    ../../../../../src/qxk/: qxk.cpp qxk_mutex.cpp qxk_sema.cpp qxk_xthr.cpp
  group QP_port
    ../../../../../ports/arm-cm/qxk/iar/: qp_port.hpp qs_port.hpp qxk_port.cpp
  group QS
    ../../../../../src/qs/: qs.cpp qs_fp.cpp qs_rx.cpp qstamp.cpp
