# Keil uVision project blinky-qv.uvprojx, settings and files
target blinky-dbg (6220000::V6.22::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: blinky-qv
  BeforeMake: cmd /c "if exist .\dbg\qstamp.o del .\dbg\qstamp.o"
  AfterMake: fromelf --bin --output .\dbg\blinky-qv.bin .\dbg\blinky-qv.axf
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..;..\..\..\..\..\include;..\..\..\..\..\ports\arm-cm\qv\armclang;..\..\..\..\..\3rd_party\CMSIS\Include;..\..\..\..\..\3rd_party\ek-tm4c123gxl
  asm define: Stack_Size=2048 Heap_Size=16
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: blinky-qv.sct
  link misc: --entry Reset_Handler
  group Applicatioin
    ../: bsp.cpp
    ../../: blinky.cpp main.cpp app.hpp bsp.hpp
  group ek-tm4c123gxl
    ../../../../../3rd_party/ek-tm4c123gxl/: system_TM4C123GH6PM.c TM4C123GH6PM.h gpio.h rom.h sysctl.h system_TM4C123GH6PM.h
    ../../../../../3rd_party/ek-tm4c123gxl/arm/: startup_TM4C123GH6PM.s
  group QP
    ../../../../../src/qf/: qep_hsm.cpp qep_msm.cpp qf_act.cpp qf_actq.cpp qf_defer.cpp qf_dyn.cpp qf_mem.cpp qf_ps.cpp qf_qact.cpp qf_qeq.cpp qf_qmact.cpp qf_time.cpp
    ../../../../../src/qv/: qv.cpp
  group QP_port
    ../../../../../ports/arm-cm/qv/armclang/: qv_port.cpp
  group QS
    ../../../../../src/qs/: qs.cpp qs_rx.cpp qstamp.cpp
target blinky-rel (6220000::V6.22::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: as above
  output: blinky-qv
  BeforeMake: cmd /c "if exist .\rel\qstamp.o del .\rel\qstamp.o"
  AfterMake: fromelf --bin --output .\rel\blinky-qv.bin .\rel\blinky-qv.axf
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG
  c include: as above
  asm define: Stack_Size=2048 Heap_Size=16
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: blinky-qv.sct
  link misc: --entry Reset_Handler
target blinky-spy (6220000::V6.22::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: as above
  output: blinky-qv
  BeforeMake: cmd /c "if exist .\spy\qstamp.o del .\spy\qstamp.o"
  AfterMake: fromelf --bin --output .\spy\blinky-qv.bin .\spy\blinky-qv.axf
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: Q_SPY
  c include: as above
  asm define: Stack_Size=2048 Heap_Size=16
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: blinky-qv.sct
  link misc: --entry Reset_Handler
