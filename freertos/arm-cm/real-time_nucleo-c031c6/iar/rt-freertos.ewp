# IAR project rt-freertos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32C031C6 ST STM32C031C6
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: STM32C031xx
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..\..\..\..\include; ..\..\..\..\..\ports\freertos; ..\..\..\..\..\3rd_party\FreeRTOS-Kernel\include; ..\..\..\..\..\3rd_party\FreeRTOS-Kernel\portable\IAR\ARM_CM0; ..\..\..\..\..\3rd_party\CMSIS\Include; ..\..\..\..\..\3rd_party\nucleo-c031c6
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..
  OBJCOPY.OOCOutputFile: rt-freertos.bin
  prebuild: cmd /c "if exist $OBJ_DIR$\qstamp.o del $OBJ_DIR$\qstamp.o"
  ILINK.IlinkOutputFile: rt-freertos.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STM32C031xx
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
configuration Spy (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: Q_SPY; STM32C031xx
  ICCARM.CCOptLevel: 1
  group app
    ../: app.hpp bsp.cpp bsp.hpp FreeRTOSConfig.h main.cpp periodic1.cpp periodic4.cpp qp_config.hpp sporadic2.cpp sporadic3.cpp
  group FreeRTOS
    ../../../../../3rd_party/FreeRTOS-Kernel/: list.c queue.c tasks.c
    ../../../../../3rd_party/FreeRTOS-Kernel/portable/IAR/ARM_CM0/: port.c portasm.s portmacro.h
  group nucleo-c031c6
    ../../../../../3rd_party/nucleo-c031c6/iar/: startup_stm32c031xx.s
    ../../../../../3rd_party/nucleo-c031c6/: stm32c031xx.h system_stm32c0xx.c
  group QP
    ../../../../../src/qf/: qep_hsm.cpp qep_msm.cpp qf_act.cpp qf_defer.cpp qf_dyn.cpp qf_mem.cpp qf_ps.cpp qf_qact.cpp qf_qeq.cpp qf_qmact.cpp qf_time.cpp
  group QP_port
    ../../../../../ports/freertos/: qf_port.cpp qp_port.hpp
  group QS
    ../../../../../src/qs/: qs.cpp qs_64bit.cpp qs_fp.cpp qs_rx.cpp qstamp.cpp
