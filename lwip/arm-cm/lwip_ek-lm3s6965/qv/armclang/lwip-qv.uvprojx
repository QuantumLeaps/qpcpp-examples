# Keil uVision project lwip-qv.uvprojx, settings and files
target lwip-dbg (6230000::V6.23::ARMCLANG)
  device: LM3S6965 Texas Instruments
  pack: Keil.LM3S_DFP.1.1.1
  cpu: IRAM(0x20000000,0x0000B800) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: lwip-qv
  BeforeMake: cmd /c "if exist .\dbg\qstamp.o del .\dbg\qstamp.o"
  AfterMake: fromelf --bin --output .\dbg\lwip-qv.bin .\dbg\lwip-qv.axf
  c flags: Optim=2 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c misc: -fno-exceptions
  c include: ..\..;..\..\..\..\..\..\include;..\..\..\..\..\..\ports\arm-cm\qv\armclang;..\..\..\..\..\..\3rd_party\CMSIS\Include;..\..\..\..\..\..\3rd_party\ek-lm3s6965;..\..\..\..\..\..\3rd_party\ek-lm3s6965\lwip_driver;..\..\..\..\..\..\3rd_party\lwip\src\include;..\..\..\..\..\..\3rd_party\lwip\src\include\ipv4;..\..\..\..\..\..\3rd_party\lwip\src;..\..\..\..\..\..\3rd_party\lwip\apps\webserver_raw
  asm define: Stack_Size=2048 Heap_Size=16
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xb800
  scatter file: .\lwip-qv.sct
  link misc: --entry Reset_Handler
  group Applicatioin
    ../../: philo.cpp table.cpp bsp.hpp main.cpp app.hpp fsdata.h lwip.c lwip.h lwipmgr.cpp lwipopts.h qp_config.hpp
    ../: bsp.cpp
  group QP
    ../../../../../../src/qf/: qep_hsm.cpp qep_msm.cpp qf_act.cpp qf_actq.cpp qf_defer.cpp qf_dyn.cpp qf_mem.cpp qf_ps.cpp qf_qact.cpp qf_qeq.cpp qf_qmact.cpp qf_time.cpp
    ../../../../../../src/qv/: qv.cpp
  group QP_port
    ../../../../../../ports/arm-cm/qv/armclang/: qv_port.cpp
  group QS
    ../../../../../../src/qs/: qs_fp.cpp qs.cpp qs_64bit.cpp qs_rx.cpp qstamp.cpp
  group ek-lm3s6965
    ../../../../../../3rd_party/ek-lm3s6965/: LM3S6965.h rit128x96x4.c rit128x96x4.h system_LM3S6965.c system_LM3S6965.h
    ../../../../../../3rd_party/ek-lm3s6965/arm/: startup_LM3S6965.s
    ../../../../../../3rd_party/ek-lm3s6965/lwip_driver/netif_cpp/: eth_driver.cpp eth_driver.hpp
  group webserver_raw
    ../../../../../../3rd_party/lwip/apps/webserver_raw/: fs.c fs.h httpd.c httpd.h
target lwip-rel (6230000::V6.23::ARMCLANG)
  device: LM3S6965 Texas Instruments
  pack: Keil.LM3S_DFP.1.1.1
  cpu: as above
  output: lwip-qv
  BeforeMake: cmd /c "if exist .\rel\qstamp.o del .\rel\qstamp.o"
  AfterMake: fromelf --bin --output .\rel\lwip-qv.bin .\rel\lwip-qv.axf
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG
  c misc: -fno-exceptions
  c include: as above
  asm define: Stack_Size=2048 Heap_Size=16
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xb800
  scatter file: .\lwip-qv.sct
  link misc: --entry Reset_Handler
target lwip-spy (6230000::V6.23::ARMCLANG)
  device: LM3S6965 Texas Instruments
  pack: Keil.LM3S_DFP.1.1.1
  cpu: as above
  output: lwip-qv
  BeforeMake: cmd /c "if exist .\spy\qstamp.o del .\spy\qstamp.o"
  AfterMake: fromelf --bin --output .\spy\lwip-qv.bin .\spy\lwip-qv.axf
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: Q_SPY
  c misc: -fno-exceptions
  c include: as above
  asm define: Stack_Size=2048 Heap_Size=16
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xb800
  scatter file: .\lwip-qv.sct
  link misc: --entry Reset_Handler
